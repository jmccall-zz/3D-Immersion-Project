# Keil uVision project Project 1_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Project 1_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h USBFS.c USBFS.h USBFS_audio.c USBFS_audio.h USBFS_boot.c USBFS_cdc.c USBFS_cdc.h USBFS_cls.c USBFS_descr.c USBFS_drv.c USBFS_episr.c USBFS_hid.c USBFS_hid.h USBFS_pm.c USBFS_std.c USBFS_vnd.c USBFS_cdc.inf USBFS_midi.c USBFS_midi.h ADC.c ADC.h ADC_PM.c ADC_INT.c SW_In_aliases.h SW_In.c SW_In.h LED_1_aliases.h LED_1.c LED_1.h PWM.c PWM.h PWM_PM.c PWM_Clock.c PWM_Clock.h LED_2_aliases.h LED_2.c LED_2.h LCD.c LCD.h LCD_PM.c USBFS_Dm_aliases.h USBFS_Dp_aliases.h USBFS_Dp.c USBFS_Dp.h ADC_theACLK.c ADC_theACLK.h ADC_Ext_CP_Clk.c ADC_Ext_CP_Clk.h ADC_AMux.c ADC_AMux.h LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h Finger1_aliases.h Finger1.c Finger1.h Finger4_aliases.h Finger4.c Finger4.h Finger3_aliases.h Finger3.c Finger3.h Finger2_aliases.h Finger2.c Finger2.h AMux_1.c AMux_1.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: Project 1_PSoC5lib (library)
